// nabo_voice.c —— 规则见 prototype/index.html 的“复读链路”
#include "nabo_voice.h"
#include <math.h>
#ifndef M_PI
#define M_PI 3.14159265358979323846
#endif
#include <string.h>

#define CLAMP(v, a, b) ((v) < (a) ? (a) : (v) > (b) ? (b) : (v))

static const int16_t STEP[89] = {7, 8, 9, 10, 11, 12, 13, 14, 16, 17, 19, 21, 23, 25, 28, 31, 34, 37, 41, 45, 50, 55, 60, 66, 73, 80, 88, 97, 107,
    118, 130, 143, 157, 173, 190, 209, 230, 253, 279, 307, 337, 371, 408, 449, 494, 544, 598, 658, 724, 796, 876, 963, 1060, 1166, 1282, 1411,
    1552, 1707, 1878, 2066, 2272, 2499, 2749, 3024, 3327, 3660, 4026, 4428, 4871, 5358, 5894, 6484, 7132, 7845, 8630, 9493, 10442, 11487,
    12635, 13899, 15289, 16818, 18500, 20350, 22385, 24623, 27086, 29794, 32767};
static const int8_t IDXT[8] = {-1, -1, -1, -1, 2, 4, 6, 8};

// sin 表：1025 项 Q15（最后一项 = 第一项，方便插值）
static const int16_t SIN[1025]={0,201,402,603,804,1005,1206,1407,1608,1809,2009,2210,2410,2611,2811,3012,3212,3412,3612,3811,4011,4210,4410,4609,4808,5007,5205,5404,5602,5800,5998,6195,6393,6590,6786,6983,7179,7375,7571,7767,7962,8157,8351,8545,8739,8933,9126,9319,9512,9704,9896,10087,10278,10469,10659,10849,11039,11228,11417,11605,11793,11980,12167,12353,12539,12725,12910,13094,13279,13462,13645,13828,14010,14191,14372,14553,14732,14912,15090,15269,15446,15623,15800,15976,16151,16325,16499,16673,16846,17018,17189,17360,17530,17700,17869,18037,18204,18371,18537,18703,18868,19032,19195,19357,19519,19680,19841,20000,20159,20317,20475,20631,20787,20942,21096,21250,21403,21554,21705,21856,22005,22154,22301,22448,22594,22739,22884,23027,23170,23311,23452,23592,23731,23870,24007,24143,24279,24413,24547,24680,24811,24942,25072,25201,25329,25456,25582,25708,25832,25955,26077,26198,26319,26438,26556,26674,26790,26905,27019,27133,27245,27356,27466,27575,27683,27790,27896,28001,28105,28208,28310,28411,28510,28609,28706,28803,28898,28992,29085,29177,29268,29358,29447,29534,29621,29706,29791,29874,29956,30037,30117,30195,30273,30349,30424,30498,30571,30643,30714,30783,30852,30919,30985,31050,31113,31176,31237,31297,31356,31414,31470,31526,31580,31633,31685,31736,31785,31833,31880,31926,31971,32014,32057,32098,32137,32176,32213,32250,32285,32318,32351,32382,32412,32441,32469,32495,32521,32545,32567,32589,32609,32628,32646,32663,32678,32692,32705,32717,32728,32737,32745,32752,32757,32761,32765,32766,32767,32766,32765,32761,32757,32752,32745,32737,32728,32717,32705,32692,32678,32663,32646,32628,32609,32589,32567,32545,32521,32495,32469,32441,32412,32382,32351,32318,32285,32250,32213,32176,32137,32098,32057,32014,31971,31926,31880,31833,31785,31736,31685,31633,31580,31526,31470,31414,31356,31297,31237,31176,31113,31050,30985,30919,30852,30783,30714,30643,30571,30498,30424,30349,30273,30195,30117,30037,29956,29874,29791,29706,29621,29534,29447,29358,29268,29177,29085,28992,28898,28803,28706,28609,28510,28411,28310,28208,28105,28001,27896,27790,27683,27575,27466,27356,27245,27133,27019,26905,26790,26674,26556,26438,26319,26198,26077,25955,25832,25708,25582,25456,25329,25201,25072,24942,24811,24680,24547,24413,24279,24143,24007,23870,23731,23592,23452,23311,23170,23027,22884,22739,22594,22448,22301,22154,22005,21856,21705,21554,21403,21250,21096,20942,20787,20631,20475,20317,20159,20000,19841,19680,19519,19357,19195,19032,18868,18703,18537,18371,18204,18037,17869,17700,17530,17360,17189,17018,16846,16673,16499,16325,16151,15976,15800,15623,15446,15269,15090,14912,14732,14553,14372,14191,14010,13828,13645,13462,13279,13094,12910,12725,12539,12353,12167,11980,11793,11605,11417,11228,11039,10849,10659,10469,10278,10087,9896,9704,9512,9319,9126,8933,8739,8545,8351,8157,7962,7767,7571,7375,7179,6983,6786,6590,6393,6195,5998,5800,5602,5404,5205,5007,4808,4609,4410,4210,4011,3811,3612,3412,3212,3012,2811,2611,2410,2210,2009,1809,1608,1407,1206,1005,804,603,402,201,0,-201,-402,-603,-804,-1005,-1206,-1407,-1608,-1809,-2009,-2210,-2410,-2611,-2811,-3012,-3212,-3412,-3612,-3811,-4011,-4210,-4410,-4609,-4808,-5007,-5205,-5404,-5602,-5800,-5998,-6195,-6393,-6590,-6786,-6983,-7179,-7375,-7571,-7767,-7962,-8157,-8351,-8545,-8739,-8933,-9126,-9319,-9512,-9704,-9896,-10087,-10278,-10469,-10659,-10849,-11039,-11228,-11417,-11605,-11793,-11980,-12167,-12353,-12539,-12725,-12910,-13094,-13279,-13462,-13645,-13828,-14010,-14191,-14372,-14553,-14732,-14912,-15090,-15269,-15446,-15623,-15800,-15976,-16151,-16325,-16499,-16673,-16846,-17018,-17189,-17360,-17530,-17700,-17869,-18037,-18204,-18371,-18537,-18703,-18868,-19032,-19195,-19357,-19519,-19680,-19841,-20000,-20159,-20317,-20475,-20631,-20787,-20942,-21096,-21250,-21403,-21554,-21705,-21856,-22005,-22154,-22301,-22448,-22594,-22739,-22884,-23027,-23170,-23311,-23452,-23592,-23731,-23870,-24007,-24143,-24279,-24413,-24547,-24680,-24811,-24942,-25072,-25201,-25329,-25456,-25582,-25708,-25832,-25955,-26077,-26198,-26319,-26438,-26556,-26674,-26790,-26905,-27019,-27133,-27245,-27356,-27466,-27575,-27683,-27790,-27896,-28001,-28105,-28208,-28310,-28411,-28510,-28609,-28706,-28803,-28898,-28992,-29085,-29177,-29268,-29358,-29447,-29534,-29621,-29706,-29791,-29874,-29956,-30037,-30117,-30195,-30273,-30349,-30424,-30498,-30571,-30643,-30714,-30783,-30852,-30919,-30985,-31050,-31113,-31176,-31237,-31297,-31356,-31414,-31470,-31526,-31580,-31633,-31685,-31736,-31785,-31833,-31880,-31926,-31971,-32014,-32057,-32098,-32137,-32176,-32213,-32250,-32285,-32318,-32351,-32382,-32412,-32441,-32469,-32495,-32521,-32545,-32567,-32589,-32609,-32628,-32646,-32663,-32678,-32692,-32705,-32717,-32728,-32737,-32745,-32752,-32757,-32761,-32765,-32766,-32767,-32766,-32765,-32761,-32757,-32752,-32745,-32737,-32728,-32717,-32705,-32692,-32678,-32663,-32646,-32628,-32609,-32589,-32567,-32545,-32521,-32495,-32469,-32441,-32412,-32382,-32351,-32318,-32285,-32250,-32213,-32176,-32137,-32098,-32057,-32014,-31971,-31926,-31880,-31833,-31785,-31736,-31685,-31633,-31580,-31526,-31470,-31414,-31356,-31297,-31237,-31176,-31113,-31050,-30985,-30919,-30852,-30783,-30714,-30643,-30571,-30498,-30424,-30349,-30273,-30195,-30117,-30037,-29956,-29874,-29791,-29706,-29621,-29534,-29447,-29358,-29268,-29177,-29085,-28992,-28898,-28803,-28706,-28609,-28510,-28411,-28310,-28208,-28105,-28001,-27896,-27790,-27683,-27575,-27466,-27356,-27245,-27133,-27019,-26905,-26790,-26674,-26556,-26438,-26319,-26198,-26077,-25955,-25832,-25708,-25582,-25456,-25329,-25201,-25072,-24942,-24811,-24680,-24547,-24413,-24279,-24143,-24007,-23870,-23731,-23592,-23452,-23311,-23170,-23027,-22884,-22739,-22594,-22448,-22301,-22154,-22005,-21856,-21705,-21554,-21403,-21250,-21096,-20942,-20787,-20631,-20475,-20317,-20159,-20000,-19841,-19680,-19519,-19357,-19195,-19032,-18868,-18703,-18537,-18371,-18204,-18037,-17869,-17700,-17530,-17360,-17189,-17018,-16846,-16673,-16499,-16325,-16151,-15976,-15800,-15623,-15446,-15269,-15090,-14912,-14732,-14553,-14372,-14191,-14010,-13828,-13645,-13462,-13279,-13094,-12910,-12725,-12539,-12353,-12167,-11980,-11793,-11605,-11417,-11228,-11039,-10849,-10659,-10469,-10278,-10087,-9896,-9704,-9512,-9319,-9126,-8933,-8739,-8545,-8351,-8157,-7962,-7767,-7571,-7375,-7179,-6983,-6786,-6590,-6393,-6195,-5998,-5800,-5602,-5404,-5205,-5007,-4808,-4609,-4410,-4210,-4011,-3811,-3612,-3412,-3212,-3012,-2811,-2611,-2410,-2210,-2009,-1809,-1608,-1407,-1206,-1005,-804,-603,-402,-201,0};
static const int16_t TANH[513]={0,256,512,768,1024,1279,1535,1790,2045,2300,2555,2809,3063,3317,3570,3822,4075,4326,4578,4828,5079,5328,5577,5825,6073,6320,6566,6811,7056,7299,7542,7784,8025,8265,8505,8743,8980,9216,9452,9686,9919,10151,10382,10611,10840,11067,11294,11519,11742,11965,12186,12406,12625,12842,13058,13273,13486,13698,13908,14118,14325,14532,14737,14940,15142,15343,15542,15740,15936,16130,16324,16515,16706,16894,17081,17267,17451,17634,17815,17995,18173,18349,18524,18697,18869,19040,19208,19376,19541,19706,19868,20029,20189,20347,20503,20658,20812,20964,21114,21263,21411,21557,21701,21844,21986,22126,22264,22401,22537,22671,22804,22935,23065,23193,23320,23446,23570,23693,23815,23935,24053,24171,24287,24401,24515,24627,24738,24847,24955,25062,25168,25272,25375,25477,25578,25677,25775,25872,25968,26063,26156,26248,26339,26429,26518,26606,26693,26778,26863,26946,27029,27110,27190,27269,27348,27425,27501,27576,27650,27723,27796,27867,27937,28007,28075,28143,28210,28275,28340,28404,28468,28530,28592,28652,28712,28771,28829,28887,28943,28999,29054,29109,29162,29215,29267,29319,29369,29419,29469,29517,29565,29612,29659,29705,29750,29795,29839,29882,29925,29967,30009,30050,30090,30130,30169,30208,30246,30284,30321,30357,30393,30429,30464,30498,30532,30566,30599,30631,30663,30695,30726,30757,30787,30817,30846,30875,30903,30932,30959,30986,31013,31040,31066,31092,31117,31142,31166,31191,31215,31238,31261,31284,31306,31329,31350,31372,31393,31414,31435,31455,31475,31494,31514,31533,31552,31570,31588,31606,31624,31641,31658,31675,31692,31708,31725,31740,31756,31772,31787,31802,31817,31831,31845,31859,31873,31887,31900,31914,31927,31940,31952,31965,31977,31989,32001,32013,32024,32036,32047,32058,32069,32080,32090,32101,32111,32121,32131,32141,32150,32160,32169,32178,32187,32196,32205,32214,32222,32230,32239,32247,32255,32263,32270,32278,32286,32293,32300,32307,32315,32322,32328,32335,32342,32348,32355,32361,32367,32374,32380,32386,32391,32397,32403,32409,32414,32420,32425,32430,32435,32440,32446,32450,32455,32460,32465,32470,32474,32479,32483,32488,32492,32496,32500,32504,32508,32512,32516,32520,32524,32528,32531,32535,32539,32542,32546,32549,32553,32556,32559,32562,32565,32569,32572,32575,32578,32581,32583,32586,32589,32592,32595,32597,32600,32602,32605,32607,32610,32612,32615,32617,32619,32622,32624,32626,32628,32630,32633,32635,32637,32639,32641,32643,32645,32647,32648,32650,32652,32654,32656,32657,32659,32661,32662,32664,32666,32667,32669,32670,32672,32673,32675,32676,32677,32679,32680,32682,32683,32684,32685,32687,32688,32689,32690,32692,32693,32694,32695,32696,32697,32698,32699,32700,32701,32702,32703,32704,32705,32706,32707,32708,32709,32710,32711,32712,32713,32713,32714,32715,32716,32717,32717,32718,32719,32720,32720,32721,32722,32723,32723,32724,32725,32725,32726,32727,32727,32728,32728,32729,32730,32730,32731,32731,32732,32732,32733,32733,32734,32735,32735,32736,32736,32736,32737,32737,32738,32738,32739,32739,32740,32740,32740,32741,32741,32742,32742,32742,32743,32743,32744,32744,32744,32745,32745};
static void tables(void) {}

// phase：周期内的位置 Q32；返回 sin Q15
static inline int32_t sin_q32(uint32_t ph) {
    uint32_t k = ph >> 22, f = (ph >> 6) & 0xFFFF;
    int32_t a = SIN[k], b = SIN[k + 1];
    return a + (((b - a) * (int32_t)f) >> 16);
}
// sin(2π·hz·i/SR)，hz 以 0.1 Hz 为单位
static inline int32_t sin_at(uint32_t i, uint32_t hz10) {
    uint64_t num = ((uint64_t)i * hz10) % ((uint64_t)NV_SR * 10);
    return sin_q32((uint32_t)((num << 32) / ((uint64_t)NV_SR * 10)));
}
static inline int32_t tanh_q15(int32_t x_q15) {   // 输入 Q15（实数 = x/32768）
    int32_t a = x_q15 < 0 ? -x_q15 : x_q15;
    int32_t u = a >> 8;                // 1/128 一格（Q15 → 32768/128 = 256）
    int32_t r = u >= 512 ? TANH[512] : TANH[u] + (((TANH[u + 1] - TANH[u]) * (a & 255)) >> 8);
    return x_q15 < 0 ? -r : r;
}

/* ---------------- 录音 ---------------- */

void nv_rec_start(nv_rec_t *r) {
    tables();
    r->n8 = 0; r->pred = 0; r->idx = 0; r->has_pend = 0; r->peak = 0;
    r->dc_q16 = 0; r->fir_pos = 0; r->level_energy = 0; r->level_n = 0;
    memset(r->fir, 0, sizeof r->fir); memset(r->levels, 0, sizeof r->levels);
}

/* Quarter-octave RMS bins. Use sustained speech, rather than a single handling
 * click or DC offset, to set playback gain. Fixed metadata; no heap allocation. */
static const uint16_t LEVEL[NV_LEVEL_BINS] = {
    32,38,45,54,64,76,91,108,128,152,181,215,256,304,362,431,512,609,724,861,
    1024,1218,1448,1722,2048,2435,2896,3444,4096,4871,5793,6889,8192,9742,
    11585,13777,16384,19484,23170,27554,32768
};
static uint32_t root_u64(uint64_t v) {
    uint64_t bit = 1ULL << 62, out = 0;
    while (bit > v) bit >>= 2;
    while (bit) {
        if (v >= out + bit) { v -= out + bit; out = (out >> 1) + bit; }
        else out >>= 1;
        bit >>= 2;
    }
    return (uint32_t)out;
}

static void encode(nv_rec_t *r, int32_t smp) {
    int32_t i = r->n8;
    nv_block_t *b = &r->blk[i / NV_BLOCK];
    if (i % NV_BLOCK == 0) { b->pred = (int16_t)r->pred; b->idx = (uint8_t)r->idx; b->pad = 0; memset(b->data, 0, sizeof b->data); }
    int32_t step = STEP[r->idx], diff = smp - r->pred, code = 0;
    if (diff < 0) { code = 8; diff = -diff; }
    int32_t vp = step >> 3;
    if (diff >= step) { code |= 4; diff -= step; vp += step; } step >>= 1;
    if (diff >= step) { code |= 2; diff -= step; vp += step; } step >>= 1;
    if (diff >= step) { code |= 1; vp += step; }
    r->pred = CLAMP(r->pred + ((code & 8) ? -vp : vp), -32768, 32767);
    r->idx = CLAMP(r->idx + IDXT[code & 7], 0, 88);
    int32_t ap = r->pred < 0 ? -r->pred : r->pred;
    if (ap > r->peak) r->peak = ap;
    int j = i % NV_BLOCK;
    b->data[j >> 1] |= (uint8_t)((code & 15) << ((j & 1) * 4));
    r->n8++;
    r->level_energy += (int64_t)r->pred * r->pred;
    if (++r->level_n == 160) {
        uint32_t rms = root_u64(r->level_energy / 160);
        int bin = 0; while (bin < NV_LEVEL_BINS - 1 && rms > LEVEL[bin]) bin++;
        r->levels[bin]++; r->level_n = 0; r->level_energy = 0;
    }
}

int nv_rec_push(nv_rec_t *r, const int16_t *x16, int n) {
    /* 15-tap 3.5 kHz low-pass before 2:1 decimation. Two-point averaging
     * previously folded high-frequency microphone noise into the voice band. */
    static const int16_t FIR[15] = {-30,197,310,-781,-1885,1587,9777,14418,
                                   9777,1587,-1885,-781,310,197,-30};
    int k = 0;
    for (; k < n; k++) {
        if (r->n8 >= NV_MAX_8K) break;
        r->dc_q16 += (int32_t)(((int64_t)x16[k] * 65536 - r->dc_q16) / 32);
        int32_t hp = x16[k] - (r->dc_q16 >> 16);
        r->fir[r->fir_pos] = (int16_t)CLAMP(hp, -32768, 32767);
        r->fir_pos = (r->fir_pos + 1) % 15;
        r->has_pend ^= 1;
        if (r->has_pend) continue;
        int64_t sum = 0;
        for (int j = 0; j < 15; j++) sum += (int32_t)r->fir[(r->fir_pos + j) % 15] * FIR[j];
        encode(r, CLAMP((sum + 16384) >> 15, -32768, 32767));
    }
    return k;
}

int32_t nv_gain_q8(const nv_rec_t *r) {
    unsigned count = 0;
    for (int i = 3; i < NV_LEVEL_BINS; i++) count += r->levels[i];
    if (!count) return 256; /* Do not turn silence/very faint noise into speech. */
    unsigned rank = (count * 4 + 4) / 5, sum = 0;
    int bin = 3;
    for (; bin < NV_LEVEL_BINS - 1; bin++) { sum += r->levels[bin]; if (sum >= rank) break; }
    int32_t g = 6000 * 256 / LEVEL[bin];
    return CLAMP(g, 64, 8192); /* Up to32x for quiet speech, unchanged codec volume. */
}

/* ---------------- 解码 ---------------- */

void nv_dec_init(nv_dec_t *d, const nv_rec_t *r) { d->rec = r; d->blk[0] = d->blk[1] = -1; d->lru = 0; }

static void decode_block(const nv_rec_t *r, int32_t k, int16_t *out) {
    const nv_block_t *b = &r->blk[k];
    int32_t pred = b->pred, idx = b->idx, n = r->n8 - k * NV_BLOCK;
    if (n > NV_BLOCK) n = NV_BLOCK;
    for (int j = 0; j < n; j++) {
        int code = (b->data[j >> 1] >> ((j & 1) * 4)) & 15;
        int32_t step = STEP[idx], vp = step >> 3;
        if (code & 4) vp += step;
        if (code & 2) vp += step >> 1;
        if (code & 1) vp += step >> 2;
        pred = CLAMP(pred + ((code & 8) ? -vp : vp), -32768, 32767);
        idx = CLAMP(idx + IDXT[code & 7], 0, 88);
        out[j] = (int16_t)pred;
    }
}

int16_t nv_dec_get(nv_dec_t *d, int32_t i) {
    if (i < 0 || i >= d->rec->n8) return 0;
    int32_t k = i / NV_BLOCK;
    for (int c = 0; c < 2; c++) if (d->blk[c] == k) { d->lru = (uint8_t)(c ^ 1); return d->buf[c][i % NV_BLOCK]; }
    int c = d->lru;
    decode_block(d->rec, k, d->buf[c]);
    d->blk[c] = k; d->lru = (uint8_t)(c ^ 1);
    return d->buf[c][i % NV_BLOCK];
}

/* ---------------- 播放 ---------------- */

// 8 kHz 位置 t（Q16）插值读取并乘增益，返回 Q15
static inline int32_t src_q16(nv_player_t *p, nv_dec_t *d, uint64_t t) {
    int32_t i = (int32_t)(t >> 16), f = (int32_t)(t & 0xFFFF);
    /* Cubic reconstruction retains consonants better than linear upsampling. */
    int32_t a = nv_dec_get(d, i - 1), b = nv_dec_get(d, i);
    int32_t c = nv_dec_get(d, i + 1), e = nv_dec_get(d, i + 2);
    int32_t q = (int32_t)((int64_t)(3 * (b - c) + e - a) * f >> 16);
    q = (int32_t)((int64_t)(2 * a - 5 * b + 4 * c - e + q) * f >> 16);
    int32_t v = b + (int32_t)((int64_t)(c - a + q) * f >> 17);
    return (int32_t)(((int64_t)v * p->g_q8) >> 8);
}
// 第 i 个输出点读 i·num/den（8 kHz 单位）
static inline int32_t src_rate(nv_player_t *p, nv_dec_t *d, uint32_t i, uint32_t num, uint32_t den) {
    return src_q16(p, d, (((uint64_t)i * num) << 16) / den);
}
// 调制延迟：从历史 x 里读 i - (D+2) - D·sin(2π·hz·i/SR)
static inline int32_t vib_read(const nv_player_t *p, uint32_t i, int32_t D, uint32_t hz10) {
    int64_t pos = ((int64_t)i << 16) - ((int64_t)(D + 2) << 16) - (int64_t)D * sin_at(i, hz10) * 2;   // D·sin(Q15)·2 = Q16
    if (pos < 0) return 0;
    int32_t k = (int32_t)(pos >> 16), f = (int32_t)(pos & 0xFFFF);
    int32_t a = p->hist[k % NV_HIST], b = p->hist[(k + 1) % NV_HIST];
    return a + (int32_t)(((int64_t)(b - a) * f) >> 16);
}

static uint32_t mulberry32(uint32_t *a) {
    *a += 0x6D2B79F5u;
    uint32_t t = *a;
    t = (t ^ (t >> 15)) * (1u | t);
    t = (t + ((t ^ (t >> 7)) * (61u | t))) ^ t;
    return t ^ (t >> 14);
}

void nv_play_start(nv_player_t *p, const nv_rec_t *r, int voice) {
    tables();
    memset(p, 0, sizeof *p);
    p->rec = r; p->voice = voice >= 0 && voice < NV_COUNT ? voice : NV_ORIGINAL; p->g_q8 = nv_gain_q8(r); p->L2 = (uint32_t)r->n8 * 2;
    nv_dec_init(&p->da, r); nv_dec_init(&p->db, r);
    uint32_t n8 = (uint32_t)r->n8;
    switch (voice) {
    case NV_CHIPMUNK: p->n_out = n8 * 4 / 3; break;
    case NV_OLDMAN:   p->n_out = n8 * 200 / 72; break;
    case NV_ALIEN:    p->n_out = n8 * 200 / 135; break;
    case NV_ECHO:     p->n_out = p->L2 + NV_SR; break;
    case NV_WALKIE:   p->n_out = p->L2 + NV_SR * 3 / 10; p->rng = 1234; break;
    case NV_LOWBAT:   p->n_out = 0; break;
    case NV_STUTTER:  p->n_out = 0; p->lcg = 1; p->seg0 = 0; p->seg_u = 0; p->seg_rep = 0; break;
    default:          p->n_out = p->L2; break;
    }
    if (!r->n8) p->done = 1;
}

uint32_t nv_play_length(const nv_player_t *p) { return p->n_out ? p->n_out : (p->done ? p->i : 0); }

// 基础流：原速 x(i) = src(i/2)，同时记进历史
static inline int32_t base_x(nv_player_t *p, uint32_t i) {
    int32_t x = i < p->L2 ? src_rate(p, &p->da, i, 1, 2) : 0;
    p->hist[i % NV_HIST] = x;
    return x;
}

static inline int32_t ramp(int32_t value, uint32_t left, uint32_t full) {
    return left >= full ? value : (int32_t)((int64_t)value * left / full);
}

/* Same phase recurrence as LOWBAT playback. The lookahead runs once, only when
 * <=80 source samples remain (<=201 output steps at its minimum0.4 speed). */
static inline uint64_t lowbat_step(uint64_t q) {
    uint64_t q2 = (q * q) >> 32;
    return (1ULL << 32) - ((q2 * 2576980378ULL) >> 32);
}
static uint32_t lowbat_remaining(uint64_t position, uint64_t length) {
    uint64_t end = (length - 1) << 32;
    uint32_t count = 0;
    while (position < end) { position += lowbat_step(position / length); count++; }
    return count;
}

static int32_t next_sample(nv_player_t *p) {
    uint32_t i = p->i;
    switch (p->voice) {
    case NV_CHIPMUNK: return src_rate(p, &p->da, i, 3, 4);
    case NV_OLDMAN:   return src_rate(p, &p->da, i, 9, 25);
    case NV_ORIGINAL: return src_rate(p, &p->da, i, 1, 2);
    case NV_REVERSE:  return src_q16(p, &p->da, ((uint64_t)(p->L2 - 1 - i)) << 15);
    case NV_ROBOT: {
        int32_t x = src_rate(p, &p->da, i, 1, 2);
        int32_t wet = (int32_t)((int64_t)x * sin_at(i, 700) >> 15);
        return (int32_t)(((int64_t)x * 3 + (int64_t)wet * 7) / 8);
    }
    case NV_ECHO: {
        int32_t x = i < p->L2 ? src_rate(p, &p->da, i, 1, 2) : 0;
        int32_t *slot = &p->echo[i % NV_ECHO_DL];
        int32_t y = x + (int32_t)(((int64_t)*slot * 29491) >> 16);    // y[i-dl]×0.45
        *slot = y;
        return (int32_t)(((int64_t)y * 55706) >> 16);                 // Clear dry voice + echoes
    }
    case NV_VIBRATO: { base_x(p, i); return vib_read(p, i, 72, 60); }
    case NV_ALIEN: {
        p->hist[i % NV_HIST] = src_rate(p, &p->da, i, 27, 40);        // 1.35 倍速的流
        return vib_read(p, i, 32, 110);
    }
    case NV_CHORUS: {
        int32_t x = base_x(p, i);
        int32_t a = vib_read(p, i, 192, 8), b = vib_read(p, i, 288, 13), hi = src_rate(p, &p->db, i, 63, 100);
        return (int32_t)(((int64_t)x * 26214 + (int64_t)a * 20972 + (int64_t)b * 20972 + (int64_t)hi * 13107) >> 16);
    }
    case NV_WALKIE: {
        if (i < p->L2) {
            int32_t x = src_rate(p, &p->da, i, 1, 2);
            /* Q8 filter state avoids audible integer-rounding bias on soft speech. */
            p->hp = (int32_t)(((int64_t)p->hp + (int64_t)(x - p->px) * 256) * 58982 / 65536);
            p->px = x;
            p->lp += (int32_t)((int64_t)(p->hp - p->lp) * 29491 / 65536);
            int32_t y = (int32_t)(((int64_t)tanh_q15(p->lp / 64) * 39322) >> 16);
            return ramp(y, p->L2 - 1 - i, NV_EDGE_RAMP);
        }
        uint32_t tail = p->n_out - p->L2, k = i - p->L2;
        int32_t nz = (int32_t)(mulberry32(&p->rng) >> 16) - 32768;          // (2R−1)·32768
        int32_t strength = CLAMP((int64_t)p->rec->peak * p->g_q8 / 256, 0, 32768);
        int32_t y = (int32_t)(((int64_t)nz * (tail - k) / tail) >> 4);
        y = (int32_t)((int64_t)y * strength / 32768); /* Silence has no radio hiss. */
        return ramp(y, k, NV_EDGE_RAMP); /* speech and hiss meet at zero */
    }
    default: return 0;
    }
}

int nv_play_fill(nv_player_t *p, int16_t *out, int n) {
    int w = 0;
    while (w < n && !p->done) {
        int32_t v;
        uint32_t end_left = UINT32_MAX;
        if (p->voice == NV_LOWBAT) {
            uint64_t L = p->L2;
            if (p->p_q32 >= ((L - 1) << 32)) { p->done = 1; break; }
            if (!p->fade_end && ((L - 1) << 32) - p->p_q32 <= ((uint64_t)NV_EDGE_RAMP << 32))
                p->fade_end = p->i + lowbat_remaining(p->p_q32, L);
            uint64_t q = p->p_q32 / L;                                   // Q32
            v = src_q16(p, &p->da, p->p_q32 >> 17);                       // p/2 → Q16
            if (q > 3650722201ULL) v = (int32_t)((int64_t)v * (int64_t)(((1ULL << 32) - q) >> 16) * 20 / 3 >> 16);   // q>0.85：×(1−q)/0.15
            p->p_q32 += lowbat_step(q);                                  // 速度 1 − 0.6q²
            end_left = p->fade_end ? p->fade_end - 1 - p->i : UINT32_MAX;
        } else if (p->voice == NV_STUTTER) {
            if (p->seg_u == 0 && p->seg_rep == 0) {                       // 新的一段
                if (p->seg0 >= p->L2) { p->done = 1; break; }
                p->lcg = (uint32_t)(((uint64_t)p->lcg * 16807) % 2147483647);
                p->seg_rep = p->lcg % 4 == 0 ? 3 : 1;
                p->seg_len = p->L2 - p->seg0 < 1760 ? p->L2 - p->seg0 : 1760;
            }
            v = src_rate(p, &p->da, p->seg0 + p->seg_u, 1, 2);
            uint32_t left = p->seg_len - 1 - p->seg_u;
            if (p->lcg % 4 == 0) {
                uint32_t edge = NV_SPLICE_RAMP;
                if (p->seg_rep < 3 && p->seg_u < edge) edge = p->seg_u;
                if (p->seg_rep > 1 && left < edge) edge = left;
                v = ramp(v, edge, NV_SPLICE_RAMP);
            }
            if (p->seg0 + p->seg_len == p->L2 && p->seg_rep == 1) end_left = left;
            if (++p->seg_u >= p->seg_len) { p->seg_u = 0; if (--p->seg_rep == 0) p->seg0 += p->seg_len; }
        } else {
            if (p->i >= p->n_out) { p->done = 1; break; }
            v = next_sample(p);
            end_left = p->n_out - 1 - p->i;
        }
        uint32_t edge = p->i < NV_EDGE_RAMP ? p->i : NV_EDGE_RAMP;
        if (end_left < edge) edge = end_left;
        /* Consistent perceived level with headroom for modulation and echoes.
         * A soft knee avoids flat-topped clipping on loud speech or mic taps. */
        static const uint16_t TRIM[NV_COUNT] = {294,333,320,256,294,282,294,294,256,410,256,256};
        v = (int32_t)((int64_t)v * TRIM[p->voice] / 256);
        int32_t a = v < 0 ? -v : v;
        if (a > 24576) {
            int32_t excess = a - 24576;
            a = 24576 + (int32_t)((int64_t)excess * 6144 / (excess + 6144));
            v = v < 0 ? -a : a;
        }
        v = ramp(v, edge, NV_EDGE_RAMP);
        out[w++] = (int16_t)CLAMP(v, -32768, 32767);
        p->i++;
    }
    return w;
}
